require recipes-core/images/core-image-minimal.bb

DESCRIPTION = "Minimal image for MCS Linux"

IMAGE_FEATURES += "empty-root-password"
